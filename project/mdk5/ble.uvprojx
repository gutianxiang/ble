# Keil uVision project ble.uvprojx, settings and files
target PCA10056 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nRF52840_BLE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_dtm;..\..\components\ble\ble_racp;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bas_c;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hrs_c;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\sensorsim;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\util;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\utf_converter;..\..\external\segger_rtt;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\App
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002260 size 0x3dda0
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../App/: main.c
  group Board_Definition
    ../../components/boards/: boards.c
  group Board_Support
    ../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Driver
    ../../modules/nrfx/drivers/src/: nrfx_adc.c nrfx_clock.c nrfx_comp.c nrfx_dppi.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_nfct.c nrfx_nvmc.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_qspi.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_systick.c nrfx_temp.c nrfx_timer.c nrfx_twi.c nrfx_twi_twim.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_wdt.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/crc16/: crc16.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target s140_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --reduce_paths
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002260 size 0x3dda0
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
